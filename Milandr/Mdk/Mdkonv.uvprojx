# Keil uVision project Mdkonv.uvprojx, settings and files
target MedKonverter (ARM-ADS)
  device: MDR1986BE93 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mdkonv +hex
  c flags: Optim=1
  c define: USE_MDR1986VE9x, RVDS_ARMCM3_LM3S102, "PACK_STRUCT_END=","ALIGN_STRUCT_END="
  c misc: --diag_suppress 550,167
  c include: .\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\CMSIS\CM3\CoreSupport;.\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR32F9Qx_StdPeriph_Driver\src;.\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\FreeRTOS_Source;.\FreeRTOS_Source\include;.\user;.\uip-1.0\uip;.\uip-1.0\apps\webserver
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c
  group user
    ./user/: main.c
    ./uip-1.0/uip/: uIP_Task.c
  group CMSIS
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
  group StdPeriph
    ./MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_eeprom.c MDR32F9Qx_iwdg.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_wwdg.c
    ./MDR32F9Qx_StdPeriph_Driver/inc/: hw_types.h
  group FreeRTOS_Source
    ./FreeRTOS_Source/: croutine.c list.c queue.c tasks.c timers.c death.c port.c FreeRTOSConfig.h heap_2.c
    ./FreeRTOS_Source/include/: FreeRTOS.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h portmacro.h
  group uIP_Source
    ./uip-1.0/apps/webserver/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
    ./uip-1.0/uip/: uip_arp.c psock.c timer.c uip.c uipopt.h
