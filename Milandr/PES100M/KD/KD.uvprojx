# Keil uVision project KD.uvprojx, settings and files
target KD_milandr (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KD +hex
  c flags: Optim=1
  c define: USE_MDR1986VE9x
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport;..\CMSIS\CM3\DeviceSupport\MDR32F9Qx;..\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\MDR32F9Qx_StdPeriph_Driver\inc;..\MDR32F9Qx_StdPeriph_Driver\src;..\KD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c
  group User
    ./: main.c
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
  group StdPeriph
    ./: MDR32F9Qx_config.h
    ../MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_eeprom.c MDR32F9Qx_dac.c MDR32F9Qx_iwdg.c
