# Keil uVision project pkmu.uvprojx, settings and files
target PKMU (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pkmu +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_MDR1986VE9x
  c include: .\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\CMSIS\CM3\CoreSupport;.\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR32F9Qx_StdPeriph_Driver\src;.\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\FreeRTOS_Source;.\FreeRTOS_Source\include;.\user;..\font
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
  group USER
    ./USER/: main.c
    ../font/: font5x7.h
  group CMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph
    ./MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_ssp.c MDR32F9Qx_eeprom.c
  group FreeRTOS
    ./FreeRTOS_Source/: croutine.c death.c list.c port.c queue.c tasks.c timers.c FreeRTOSConfig.h heap_1.c
