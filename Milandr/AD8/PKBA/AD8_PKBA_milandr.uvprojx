# Keil uVision project AD8_PKBA_milandr.uvprojx, settings and files
target PKBA milandr (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AD8_PKBA_milandr +hex
  c flags: Optim=1
  c define: USE_MDR1986VE9x
  c include: ..\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\CMSIS\CM3\CoreSupport;..\PKBA;..\MDR32F9Qx_StdPeriph_Driver;..\MDR32F9Qx_StdPeriph_Driver\inc;..\MDR32F9Qx_StdPeriph_Driver\src;..\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ../CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c
  group user
    ./: main.c link_pult.c
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
  group StdPeriph
    ../MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_iwdg.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_wwdg.c MDR32F9Qx_adc.c MDR32F9Qx_bkp.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_i2c.c
    ./: MDR32F9Qx_config.h
