# Keil uVision project test_FreeRTOS.uvprojx, settings and files
target Test_FreeRTOS (ARM-ADS)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mdkonv +hex
  c flags: Optim=1
  c define: USE_MDR1986VE9x, RVDS_ARMCM3_LM3S102, "PACK_STRUCT_END=","ALIGN_STRUCT_END="
  c misc: --diag_suppress 550,167
  c include: .\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\CMSIS\CM3\CoreSupport;.\MDR32F9Qx_StdPeriph_Driver;.\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR32F9Qx_StdPeriph_Driver\src;.\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\FreeRTOS_Source;.\FreeRTOS_Source\include;.\user;.\uip-1.0\uip;.\uip-1.0\apps\webserver
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c
  group user
    ./user/: main.c joystick.c leds.c KS0108.c KS0108-milandr.c graphic.c
    ./uip-1.0/uip/: uIP_Task.c
  group CMSIS
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
  group StdPeriph
    ./MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_dac.c MDR32F9Qx_eeprom.c MDR32F9Qx_iwdg.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_wwdg.c MDR32F9Qx_ebc.c
  group FreeRTOS_source
    ./FreeRTOS_Source/: croutine.c death.c heap_1.c list.c port.c queue.c tasks.c timers.c FreeRTOSConfig.h
  group uIP_source
    ./uip-1.0/uip/: psock.c timer.c uip.c uip_arp.c uipopt.h
    ./uip-1.0/apps/webserver/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
