# Keil uVision project test_AD16.uvprojx, settings and files
target TEST_AD16 (ARM-ADS)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test_AD16 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_MDR1986VE9x, RVDS_ARMCM3_LM3S102, "PACK_STRUCT_END=","ALIGN_STRUCT_END="
  c include: .\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\CMSIS\CM3\CoreSupport;.\MDR32F9Qx_StdPeriph_Driver;.\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR32F9Qx_StdPeriph_Driver\src;.\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\FreeRTOS_Source;.\FreeRTOS_Source\include;.\user;.\uip-1.0\uip;.\uip-1.0\apps\webserver
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
  group USER
    ./USER/: main.c font5x8.h graphic.c graphic.h joystick.c joystick.h KS0108.c KS0108.h KS0108-milandr.c leds.c leds.h types.h
  group StdPeriph
    ./MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c
  group CMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
  group FreeRTOS
    ./FreeRTOS_Source/: croutine.c death.c list.c port.c queue.c tasks.c timers.c FreeRTOSConfig.h heap_2.c
