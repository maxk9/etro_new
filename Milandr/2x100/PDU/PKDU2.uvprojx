# Keil uVision project PKDU2.uvprojx, settings and files
target PKDU (ARM-ADS)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PKDU2 +hex
  c flags: Optim=1
  c define: USE_MDR1986VE9x, RVDS_ARMCM3_LM3S102, "PACK_STRUCT_END=","ALIGN_STRUCT_END="
  c include: .\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\CMSIS\CM3\CoreSupport;.\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR32F9Qx_StdPeriph_Driver\src;.\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\FreeRTOS_Source;.\FreeRTOS_Source\include;.\user;.\uip-1.0\uip
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c startup_MDR32F9Qx.s
  group user
    ./user/: main.c ethconfig.c UDP_Task.c smirnov_task.c udp_frame.h font5x7.h
  group CMSIS
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
  group StdPeriph
    ./MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_wwdg.c MDR32F9Qx_ebc.c MDR32F9Qx_ssp.c
  group FreeRTOS
    ./FreeRTOS_Source/: croutine.c list.c queue.c tasks.c timers.c heap_1.c death.c port.c FreeRTOSConfig.h
